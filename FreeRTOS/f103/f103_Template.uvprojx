# Keil uVision project f103_Template.uvprojx, settings and files
target f103_Template (6210000::V6.21::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: f103_Template +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: -Wno-padded -Wno-unsafe-buffer-usage -Wno-reserved-identifier -Wno-missing-noreturn -Wno-covered-switch-default -Wno-switch-enum -Wno-missing-prototypes -Wno-newline-eof -Wno-gnu-pointer-arith -Wno-declaration-after-statement
  c include: Drivers\CMSIS\Device\ST\STM32F1xx\Include;Drivers\STM32F1xx_HAL_Driver\Inc;Drivers\CMSIS\Include;Drivers\bsp\Inc;Drivers\system\Inc;RTE\_Template;.eide\deps;Application\Inc;Middlewares\Inc;Middlewares\Third_Party;Application\Third_Party;Drivers\bsp\Third_Party;Middlewares\Third_Party\FreeRTOS\include;Middlewares\Third_Party\FreeRTOS\portable\GCC\ARM_CM3
  asm define: USE_HAL_DRIVER,STM32F103xE
  library: MicroLIB
  memory RVCT1: ROM 0x08000000 size 0x10000
  memory RVCT6: RAM 0x20000000 size 0x5000
  group Startup
    Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Readme
    ./: README.md
  group Middleware/FreeRTOS_Port
    Middlewares/Third_Party/FreeRTOS/portable/GCC/ARM_CM3/: port.c
    Middlewares/Third_Party/FreeRTOS/portable/MemMang/: heap_4.c
  group Middleware/FreeRTOS_Core
    Middlewares/Third_Party/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Drivers/system
    Drivers/system/Src/: delay.c sys.c
  group Drivers/STM32F1xx_HAL_Driver
    Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_adc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_gpio.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal.c stm32f1xx_ll_fsmc.c
  group Drivers/bsp
    Drivers/bsp/Src/: dma_uart.c key.c led.c ring_fifo.c uart.c
  group Application
    Application/Src/: main.c rtos_tasks.c stm32f1xx_it.c
    Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
